# Keil uVision project tm1629.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5206AD STC-STC12
  cpu: IRAM(0-0xFF) IROM(0-0x17FF) CLOCK(45000000)
  output: tm1629 +hex
  c flags: SizeSpeed=1
  c include: D:\Keil\C51\INC
  group Source Group 1
    ./: STARTUP.A51 watchdog.c eeprom.c key.c Delay.c systemInit.c DS18B20.c TM1629.c main.c work_mode.c DS1302.c adc.c timer.c
